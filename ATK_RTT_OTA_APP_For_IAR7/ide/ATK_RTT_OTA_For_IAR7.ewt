<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>rtthread</name>
    <group>
      <name>components</name>
      <group>
        <name>finsh</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\cmd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_compiler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_error.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_heap.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_init.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_node.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_ops.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_parser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_token.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_var.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\finsh_vm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\msh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\msh_file.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\shell.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\finsh\symbol.c</name>
        </file>
      </group>
      <group>
        <name>libc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\libc\compilers\armlibc\libc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\libc\compilers\armlibc\mem_std.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\libc\compilers\armlibc\stdio.c</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\drivers\src\completion.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\drivers\src\dataqueue.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>hal_lib</name>
      <group>
        <name>cmsis</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f407xx.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Source\Templates\system_stm32f4xx.c</name>
        </file>
      </group>
      <group>
        <name>hal</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_adc_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_can.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_cortex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_flash_ramfunc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_rcc_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_tim_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Src\stm32f4xx_hal_usart.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>libcpu</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\libcpu\arm\cortex-m4\cpuport.c</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\clock.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\components.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\cpu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\device.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\idle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\ipc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\irq.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\kservice.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\memheap.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\mempool.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\scheduler.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\signal.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\slab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\thread.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\src\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>rtthread_user</name>
    <group>
      <name>DRV</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\HAL_Drivers\drv_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\bsp\stm32\libraries\HAL_Drivers\drv_usart.c</name>
      </file>
    </group>
    <group>
      <name>DRV_FRAME</name>
      <group>
        <name>misc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\drivers\misc\pin.c</name>
        </file>
      </group>
      <group>
        <name>serial</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\components\drivers\serial\serial.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\src\board\board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\board.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\context_iar.S</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\rtconfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\board\stm32f4xx_hal_conf.h</name>
    </file>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <file>
        <name>$PROJ_DIR$\..\src\app\led_app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\src\app\user_cmd.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <group>
        <name>APL</name>
      </group>
      <group>
        <name>BSP</name>
        <file>
          <name>$PROJ_DIR$\..\common\BSP\msp_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\BSP\msp_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\BSP\msp_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\BSP\stm32f4xx_hal_msp.c</name>
        </file>
      </group>
      <group>
        <name>CmBacktrace</name>
        <file>
          <name>$PROJ_DIR$\..\common\CmBacktrace\cm_backtrace\cm_backtrace.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\CmBacktrace\cm_backtrace\cmb_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\CmBacktrace\cm_backtrace\cmb_def.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\CmBacktrace\cm_backtrace\fault_handler\iar\cmb_fault.S</name>
        </file>
      </group>
      <group>
        <name>DRV</name>
        <file>
          <name>$PROJ_DIR$\..\common\DRV\drv_common_app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\DRV\flash\flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\DRV\LED\led_drv.c</name>
        </file>
      </group>
    </group>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\ATK_CONFIG\config.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\src\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\src\readme\readme.txt</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm32f407xG_user.icf</name>
  </file>
</project>


