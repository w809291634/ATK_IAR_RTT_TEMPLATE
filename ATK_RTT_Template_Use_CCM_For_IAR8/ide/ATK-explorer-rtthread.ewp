# IAR project ATK-explorer-rtthread.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa050,Pa093
  ICCARM.CCIncludePath2: ..\..\components\finsh; ..\..\components\drivers\include; ..\..\components\drivers\spi; ..\..\components\libc\compilers\common; ..\..\components\drivers\spi\sfud\inc; ..\..\include\libc; ..\..\include; ..\..\bsp\stm32\libraries\HAL_Drivers; ..\..\bsp\stm32\libraries\HAL_Drivers\drv_flash; ..\..\bsp\stm32\libraries\HAL_Drivers\config; ..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; ..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Include; ..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\src\board; ..\src; ..\src\app; ..\common\DRV; ..\common\CmBacktrace\cm_backtrace\Languages\en-US; ..\common\CmBacktrace\cm_backtrace\Languages\zh-CN; ..\common\CmBacktrace\cm_backtrace
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\board
  OBJCOPY.OOCOutputFile: ATK-explorer-rtthread.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: D:\RT-Thread-project\4.0.3\ATK_OTA_Project\ide\stm32f407xG_user.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group rtthread
    ../src/board/: board.c board.h context_iar.S rtconfig.h
  group rtthread/DEV/hal_drv
    ../../bsp/stm32/libraries/HAL_Drivers/: drv_gpio.c drv_pwm.c drv_spi.c drv_usart.c
  group rtthread/DEV/rtc
    ../../bsp/stm32/libraries/HAL_Drivers/: drv_rtc.c
  group rtthread/libcpu
    ../../libcpu/arm/cortex-m4/: cpuport.c
  group rtthread/module/drivers/misc
    ../../components/drivers/misc/: pin.c
  group rtthread/module/drivers/rtc
    ../../components/drivers/rtc/: alarm.c rtc.c soft_rtc.c
  group rtthread/module/drivers/serial
    ../../components/drivers/serial/: serial.c
  group rtthread/module/drivers/spi
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group rtthread/module/finsh
    ../../components/finsh/: cmd.c finsh.h finsh_api.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_file.c shell.c shell.h symbol.c
  group rtthread/module/src
    ../../components/drivers/src/: completion.c dataqueue.c
  group rtthread/src
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group zproject
    ../src/: main.c
    ./: stm32f407xG_user.icf
  group zproject/app
    ../src/app/: led_app.c
  group zproject/common/BSP
    ../common/BSP/: msp_spi.c msp_tim.c msp_uart.c stm32f4xx_hal_msp.c
  group zproject/common/cm_backtrace
    ../common/CmBacktrace/cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../common/CmBacktrace/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group zproject/common/DRV
    ../common/DRV/: appdrv_common.c
    ../common/DRV/LED/: led_drv.c
  group zproject/common/LIB
    ../src/board/: stm32f4xx_hal_conf.h
  group zproject/common/LIB/cmsis
    ../../bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group zproject/common/LIB/hal
    ../../bsp/stm32/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_tim.c
