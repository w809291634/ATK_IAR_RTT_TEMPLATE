# Keil uVision project intelligent_terminal_by_explorer_app2.uvprojx, settings and files
target intelligent_terminal_by_explorer (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: intelligent_terminal_by_explorer_app2 +hex
  AfterMake: fromelf --bin --output "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1,__FPU_PRESENT =1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\FreeRTOS\components\CLI;..\CmBacktrace\cm_backtrace;..\CmBacktrace\cm_backtrace\Languages\zh-CN;..\HARDWARE\usart;..\APP\app_data_protocol;..\APP\esp32_at_transmission;..\HARDWARE\KEY;..\APP;..\config;..\STemWin544\inc;..\STemWin544\Config;..\HARDWARE;..\..\ATK_CONFIG
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\SCT\intelligent_terminal_by_explorer.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
    ../OBJ/: intelligent_terminal_by_explorer.map
    ../SCT/: intelligent_terminal_by_explorer.sct
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIMER/: cpu_usage_timer.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_tim.c
  group README
    ../: readme.txt
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/include/: FreeRTOS.h
  group FreeRTOS/port
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group FreeRTOS/components
    ../FreeRTOS/components/CLI/: FreeRTOS_CLI.c Sample-CLI-commands.c serial.c UARTCommandConsole.c FreeRTOS_CLI.h serial.h
  group CmBacktrace
    ../CmBacktrace/cm_backtrace/fault_handler/keil/: cmb_fault.S
    ../CmBacktrace/cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h cm_backtrace.h
    ../CmBacktrace/cm_backtrace/Languages/zh-CN/: cmb_zh_CN.h cmb_zh_CN_UTF8.h
  group APP
    ../APP/app_data_protocol/: app_data_protocol.c
    ../APP/esp32_at_transmission/: esp32_at.c
    ../APP/apl_key/: apl_key.c
    ../APP/GUI_app/: gui_thread.c gui_thread.h
  group config
    ../config/: config.h
    ./: FreeRTOSConfig.h
  group STemWin544
    ../STemWin544/: STemWin_CM4_wc16.a
    ../STemWin544/OS/: GUI_X.c
    ../STemWin544/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUIConf.h LCDConf.h
  group GUI_WIN
    ../APP/GUI_app/icons/: icon_unlock_arrow.c icon_smile.c
    ../APP/GUI_app/fonts/: font_songti_38_bold_ascii_unicode.c
    ../APP/GUI_app/window/: win_lockWinDLG.c win_mainpageDLG.c win_status_barDLG.c win_car_controlDLG .c
  group GUI_ICONVIEW
    ../APP/GUI_app/iconview/50x50/: iconview_appstore.c iconview_calculator.c iconview_calendar.c iconview_camera.c iconview_contacts.c iconview_menssages.c iconview_music.c iconview_phone.c iconview_photos.c iconview_safari.c iconview_settings.c iconview_siri.c iconview_videos.c iconview_weather.c
