# IAR project ATK_RTT_OTA_APP2_For_IAR7.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\components\finsh; ..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; ..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Include; ..\..\..\bsp\stm32\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\bsp\stm32\libraries\HAL_Drivers; ..\..\..\components\drivers\include; ..\..\..\bsp\stm32\libraries\HAL_Drivers\config; ..\..\..\components\drivers\include; ..\src; ..\src\app; ..\src\board; ..\src\finsh_cmd; ..\Common\APL\apl_led; ..\Common\BSP; ..\Common\DEV; ..\Common\DRV\drv_led; ..\Common\CmBacktrace\cm_backtrace; ..\Common\CmBacktrace\cm_backtrace\Languages\zh-CN; ..\Common\CmBacktrace\cm_backtrace\Languages\en-US; ..\Common\DRV\; ..\Common\DRV\flash\; ..\..\ATK_CONFIG\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\src\board
  OBJCOPY.OOCOutputFile: ATK_OTA_APP2.bin
  ILINK.IlinkOutputFile: atk_rtt_template.out
  ILINK.IlinkIcfFile: stm32f407xG_app2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: main.c
    ../src/readme/: readme.txt
    ./: stm32f407xG_user.icf
  group rtthread/components/finsh
    ../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
  group rtthread/components/libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c
  group rtthread/components/src
    ../../../components/drivers/src/: completion.c dataqueue.c
  group rtthread/hal_lib/cmsis
    ../../../bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    ../../../bsp/stm32/libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group rtthread/hal_lib/hal
    ../../../bsp/stm32/libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group rtthread/libcpu
    ../../../libcpu/arm/cortex-m4/: cpuport.c
  group rtthread/src
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group rtthread_user
    ../src/board/: board.c board.h context_iar.S rtconfig.h stm32f4xx_hal_conf.h
  group rtthread_user/DRV
    ../../../bsp/stm32/libraries/HAL_Drivers/: drv_gpio.c drv_usart.c
  group rtthread_user/DRV_FRAME/misc
    ../../../components/drivers/misc/: pin.c
  group rtthread_user/DRV_FRAME/serial
    ../../../components/drivers/serial/: serial.c
  group zonesion/app
    ../src/app/: led_app.c user_cmd.c
  group zonesion/common/BSP
    ../common/BSP/: msp_spi.c msp_tim.c msp_uart.c stm32f4xx_hal_msp.c
  group zonesion/common/CmBacktrace
    ../common/CmBacktrace/cm_backtrace/: cm_backtrace.c cmb_cfg.h cmb_def.h
    ../common/CmBacktrace/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group zonesion/common/DRV
    ../common/DRV/: drv_common_app.c
    ../common/DRV/flash/: flash.c
    ../common/DRV/LED/: led_drv.c
