<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\ATK_RTT_OTA_APP1_For_IAR7.ewp</path>
  </project>
  <batchBuild/>
</workspace>
