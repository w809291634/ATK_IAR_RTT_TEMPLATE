# Keil uVision project atk_bootloader.uvprojx, settings and files
target atk_bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: atk_bootloader +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\CORE;..\SYSTEM\systick;..\SYSTEM\sys;..\SYSTEM\soft_timer;..\USER;..\FWLIB\inc;..\SHELL;..\DRV\usart;..\DRV\LED;..\OTA;..\DRV\flash;..\..\ATK_CONFIG;..\IAP;..\SYSTEM\app_start;..\LIB\cJSON;..\LIB\jsmn
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../../ATK_CONFIG/: sys_config.h
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_flash.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/systick/: systick.c
    ../SYSTEM/soft_timer/: soft_timer.c
  group OUTPUT
    ../OBJ/: atk_bootloader.map
  group SHELL
    ../SHELL/: shell.c user_cmd.c
  group DRV
    ../DRV/usart/: usart1.c usart3.c
    ../DRV/LED/: led.c
    ../DRV/flash/: flash.c
  group IAP
    ../IAP/: download.c ymodem.c
    ../SYSTEM/app_start/: app_start.c
  group OTA
    ../OTA/: ota.c esp32_8266_at.c
